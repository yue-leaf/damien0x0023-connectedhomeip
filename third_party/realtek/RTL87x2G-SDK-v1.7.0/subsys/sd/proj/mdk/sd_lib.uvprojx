# Keil uVision project sd_lib.uvprojx, settings and files
target sd (6170000::V6.17::.\ARMCompiler6.17)
  device: ARMv81MML_DSP_DP_MVE_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("ARMV81MML") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: sd +hex (library)
  AfterMake: after_build_special.bat
  c flags: Optim=7 v6Lang=3 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X2G, BUILD_WITH_FTL=1
  c misc: -gdwarf-3
  c include: ..\..\..\..\include\rtl87x2g;..\..\..\..\include\rtl87x2g\cmsis\Core\Include;..\..\..\osif\inc;..\..\..\..\bsp\sdk_lib\inc;..\..\..\..\bsp\driver;..\..\..\..\bsp\driver\nvic\inc;..\..\..\..\bsp\driver\pinmux\inc;..\..\..\..\bsp\driver\rcc\inc;..\..\..\..\bsp\driver\tim\inc;..\..\..\..\bsp\driver\uart\inc;..\..\..\..\bsp\driver\spi\inc;..\..\..\..\bsp\driver\i2c\inc;..\..\src
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group src
    ../../src/: sd.c sdcard.c mmc.c rtl_sdhc.c
