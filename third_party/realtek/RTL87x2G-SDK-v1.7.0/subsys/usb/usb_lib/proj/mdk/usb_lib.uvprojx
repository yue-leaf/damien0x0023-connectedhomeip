# Keil uVision project usb_lib.uvprojx, settings and files
target usb (6220000::V6.22::.\ArmCompilerforEmbedded6.22)
  device: ARMv81MML_DSP_DP_MVE_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("ARMV81MML") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: usb +hex (library)
  AfterMake: after_build_special.bat
  c flags: Optim=7 v6Lang=3 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X2G, BUILD_WITH_FTL=1
  c misc: -gdwarf-3 -include port_macro.h
  c include: ..\..\inc;..\..\inc_int;..\;..\..\inc\class;..\..\inc\composite;..\..\..\..\..\bsp\driver\nvic\inc;..\..\..\..\..\bsp\driver\pinmux\inc;..\..\..\..\..\bsp\driver\pinmux\src\rtl87x2g;..\..\..\..\..\bsp\driver\rcc\inc;..\..\..\..\..\bsp\driver;..\..\..\..\..\bsp\driver\project\rtl87x2g\inc;..\..\..\..\..\bsp\driver\gpio\inc;..\..\..\..\..\bsp\driver\wdt\inc;..\..\..\..\..\bsp\driver\spi\inc;..\..\..\..\..\bsp\driver\tim\inc;..\..\..\..\..\bsp\driver\uart\inc;..\..\..\..\..\bsp\driver\i2c\inc;..\..\..\..\..\bsp\driver\adc\inc;..\..\..\..\..\bsp\driver\can\inc;..\..\..\..\..\bsp\driver\dma\inc;..\..\..\..\..\bsp\driver\ethernet\inc;..\..\..\..\..\bsp\driver\imdc\inc;..\..\..\..\..\bsp\driver\ir\inc;..\..\..\..\..\bsp\driver\iso7816\inc;..\..\..\..\..\bsp\driver\keyscan\inc;..\..\..\..\..\bsp\driver\lcdc\inc;..\..\..\..\..\bsp\driver\lpc\inc;..\..\..\..\..\bsp\driver\mipi\inc;..\..\..\..\..\bsp\driver\ppe\inc;..\..\..\..\..\bsp\driver\qdec\inc;..\..\..\..\..\bsp\driver\rtc\inc;..\..\..\..\..\bsp\driver\segcom\inc;..\..\..\..\..\bsp\driver\spi3w\inc;..\..\..\..\..\bsp\driver\nvic\inc;..\..\..\..\..\bsp\driver\pinmux\inc;..\..\..\..\..\bsp\driver\pinmux\src\rtl87x2g;..\..\..\..\..\bsp\driver\rcc\inc;..\..\..\..\..\bsp\driver;..\..\..\..\..\bsp\driver\project\rtl87x2g\inc;..\..\..\..\..\bsp\driver\gpio\inc;..\..\..\..\..\bsp\driver\wdt\inc;..\..\..\..\..\bsp\driver\spi\inc;..\..\..\..\..\bsp\driver\tim\inc;..\..\..\..\..\bsp\driver\uart\inc;..\..\..\..\..\bsp\driver\i2c\inc;..\..\..\..\..\bsp\driver\adc\inc;..\..\..\..\..\bsp\driver\can\inc;..\..\..\..\..\bsp\driver\dma\inc;..\..\..\..\..\bsp\driver\ethernet\inc;..\..\..\..\..\bsp\driver\imdc\inc;..\..\..\..\..\bsp\driver\ir\inc;..\..\..\..\..\bsp\driver\iso7816\inc;..\..\..\..\..\bsp\driver\keyscan\inc;..\..\..\..\..\bsp\driver\lcdc\inc;..\..\..\..\..\bsp\driver\lpc\inc;..\..\..\..\..\bsp\driver\mipi\inc;..\..\..\..\..\bsp\driver\ppe\inc;..\..\..\..\..\bsp\driver\qdec\inc;..\..\..\..\..\bsp\driver\rtc\inc;..\..\..\..\..\bsp\driver\segcom\inc;..\..\..\..\..\bsp\driver\spi3w\inc\usb;..\..\inc;..\..\..\usb_hal\inc\hal;..\..\..\usb_hal\inc;..\..\src\isr;..\..\src\task;..\..\src\dm;..\..\..\..\..\samples\module_sample\usb\usb_hid_mouse\src\hid;..\..\..\..\osif\inc;..\..\..\..\..\bsp\driver\rtl87x2g\project\inc;..\..\..\..\..\include\rtl87x2g;..\..\..\..\..\include\rtl87x2g\cmsis\Core\Include;..\..\..\..\..\bsp\sdk_lib\inc;..\..\..\..\..\bsp\driver\rtl87x2g\inc;..\..\..\inc;..\..\..\usb_hal\inc\bc12
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group composite
    ../../src/composite/: usb_composite_dev.c usb_dev_driver.c
    ../../src/class/hid/: usb_hid_driver.c
    ../../../../../bsp/driver/nvic/src/rtl87x2g/: rtl_nvic.c
    ../../src/class/cdc/: usb_cdc_driver.c
    ../../src/class/audio/: usb_audio_driver.c
  group dm
    ../../src/dm/: usb_dm.c
  group isr
    ../../src/isr/: usb_isr.c
  group pipe
    ../../src/pipe/: usb_pipe.c
  group task
    ../../src/task/: usb_task.c
