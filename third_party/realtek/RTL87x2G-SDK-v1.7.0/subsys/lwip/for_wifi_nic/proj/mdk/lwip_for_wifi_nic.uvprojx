# Keil uVision project lwip_for_wifi_nic.uvprojx, settings and files
target lwip_for_wifi_nic (6170000::V6.17::.\ARMCompiler6.17)
  device: ARMv81MML_DSP_DP_MVE_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("ARMV81MML") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: lwip (library)
  AfterMake: after_build_script.bat $J #L @L $P $L
  c flags: Optim=7 v6Lang=5 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X2G, DLPS_EN=0 TEMP_BUILD_OS_IN_NS_ROM
  c misc: -gdwarf-3
  c include: ..\..\..\..\..\subsys\osif\inc;..\..\..\..\..\subsys\freertos;..\..\..\..\..\include\rtl87x2g;..\..\..\..\..\include\rtl87x2g\cmsis\Core\Include;..\..\..\..\..\bsp\sdk_lib\inc;..\..\..\..\..\bsp\driver\rtl8762g\inc;..\..\..\repo\include;..\..\arch;..\..\..\for_wifi_nic;..\..\proj
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  group lwip/api
    ../../../repo/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/core
    ../../../repo/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../repo/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/netif
    ../../../repo/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
