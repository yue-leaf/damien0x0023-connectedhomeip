# Keil uVision project rtl87x2g_io_lib.uvprojx, settings and files
target src (6220000::V6.22::.\ArmCompilerforEmbedded6.22)
  device: ARMv81MML_DSP_DP_MVE_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("ARMV81MML") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: rtl87x2g_io +hex (library)
  AfterMake: after_build_special.bat
  c flags: Optim=7 v6Lang=3 v6LangP=1 wLevel=3
  c define: BUILD_WITH_FTL=1 RTL87x2G CONFIG_SOC_SERIES_RTL87X2G
  c misc: -Wno-implicit-function-declaration -gdwarf-3
  c include: ..\..\..\..\..\..\include\rtl87x2g;..\..\..\..\..\..\include\rtl87x2g\cmsis\Core\Include;..\..\..\..\..\..\include\rtl87x2g\nsc;..\..\..\..\;..\..\..\..\adc\inc;..\..\..\..\can\inc;..\..\..\..\dma\inc;..\..\..\..\gpio\inc;..\..\..\..\i2c\inc;..\..\..\..\imdc\inc;..\..\..\..\ir\inc;..\..\..\..\keyscan\inc;..\..\..\..\lcdc\inc;..\..\..\..\lpc\inc;..\..\..\..\ppe\inc;..\..\..\..\rcc\inc;..\..\..\..\spi\inc;..\..\..\..\tim\inc;..\..\..\..\uart\inc;..\..\..\..\wdt\inc;..\..\..\..\qdec\inc;..\..\..\..\iso7816\inc;..\..\..\..\spi3w\inc;..\..\..\..\rtc\inc;..\..\..\..\nvic\inc;..\..\..\..\pinmux\inc;..\..\..\..\segcom\inc;..\..\..\..\codec\src\rtl87x2g;..\..\..\..\i2s\inc;..\..\..\..\imdc\src\rtl87x2g;..\..\..\..\spi3w\inc;..\..\..\..\..\sdk_lib\inc_int;..\..\..\..\..\..\..\ROMExport\rtl87x2g\inc\nsc
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group rtl87x2g
    ../../../../adc/src/rtl87x2g/: rtl87x2g_adc.c rtl87x2g_hradc.c
    ../../../../wdt/src/rtl87x2g/: rtl87x2g_aon_wdt.c rtl87x2g_wdt.c
    ../../../../dma/src/rtl87x2g/: rtl87x2g_gdma.c
    ../../../../gpio/src/rtl87x2g/: rtl87x2g_gpio.c
    ../../../../i2c/src/rtl87x2g/: rtl87x2g_i2c.c
    ../../../../ir/src/rtl87x2g/: rtl87x2g_ir.c
    ../../../../keyscan/src/rtl87x2g/: rtl87x2g_keyscan.c
    ../../../../lpc/src/rtl87x2g/: rtl87x2g_lpc.c
    ../../../../spi/src/rtl87x2g/: rtl87x2g_spi.c
    ../../../../tim/src/rtl87x2g/: rtl87x2g_tim.c rtl87x2g_enh_tim.c
    ../../../../uart/src/rtl87x2g/: rtl87x2g_uart.c
    ../../../../spi3w/src/rtl87x2g/: rtl87x2g_spi3w.c
    ../../../../rtc/src/rtl87x2g/: rtl87x2g_rtc.c
    ../../../lib/rtl87x2g/mdk/: rtl87x2g_can.lib rtl87x2g_adc.lib
  group common
    ../../../../adc/src/rtl_common/: rtl_adc.c rtl_hradc.c
    ../../../../qdec/src/rtl_common/: rtl_aon_qdec.c
    ../../../../codec/src/rtl87x2g/: rtl_codec.c
    ../../../../tim/src/rtl_common/: rtl_enh_tim.c rtl_tim.c
    ../../../../ethernet/src/rtl_common/: rtl_ethernet.c
    ../../../../dma/src/rtl_common/: rtl_gdma.c
    ../../../../gpio/src/rtl_common/: rtl_gpio.c
    ../../../../i2c/src/rtl_common/: rtl_i2c.c
    ../../../../i2s/src/rtl_common/: rtl_i2s.c
    ../../../../ir/src/rtl_common/: rtl_ir.c
    ../../../../iso7816/src/rtl_common/: rtl_iso7816.c
    ../../../../imdc/src/rtl_common/: rtl_imdc.c
    ../../../../keyscan/src/rtl_common/: rtl_keyscan.c
    ../../../../lcdc/src/rtl_common/: rtl_lcdc.c rtl_lcdc_dbib.c rtl_lcdc_dphy.c rtl_lcdc_edpi.c rtl_ramless_qspi.c
    ../../../../lpc/src/rtl_common/: rtl_lpc.c
    ../../../../nvic/src/rtl87x2g/: rtl_nvic.c
    ../../../../pinmux/src/rtl87x2g/: rtl_pinmux.c
    ../../../../ppe/src/rtl_common/: rtl_ppe.c
    ../../../../rcc/src/rtl87x2g/: rtl_rcc.c
    ../../../../rtc/src/rtl_common/: rtl_rtc.c
    ../../../../segcom/src/rtl_common/: rtl_segcom.c
    ../../../../spi/src/rtl_common/: rtl_spi.c
    ../../../../spi3w/src/rtl_common/: rtl_spi3w.c
    ../../../../uart/src/rtl_common/: rtl_uart.c
