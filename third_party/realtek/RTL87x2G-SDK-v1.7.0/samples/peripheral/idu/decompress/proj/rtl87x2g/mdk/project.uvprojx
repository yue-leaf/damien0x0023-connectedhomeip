# Keil uVision project project.uvprojx, settings and files
target idu (6220000::V6.22::.\ArmCompilerforEmbedded6.22)
  device: ARMv81MML_DSP_DP_MVE_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("ARMV81MML") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: app_ns +hex
  AfterMake: after_build_script.bat $J #L @L $P $L
  c flags: Optim=7 v6Lang=3 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X2G, CONFIG_REALTEK_LOWERSTACK_LIB
  c misc: -gdwarf-3
  c include: ..;..;..\firmware;..\..\..\..\..\..\..\include\rtl87x2g\nsc;..\..\..\..\..\..\..\bsp\power;..\..\..\..\..\..\..\bsp\sdk_lib\inc;..\..\..\..\..\..\..\include\rtl87x2g;..\..\..\..\..\..\..\bsp\sdk_lib\inc;..\..\..\..\..\..\..\include\rtl87x2g;..\..\..\..\..\..\..\subsys\bluetooth\gap_ext\lib\rtl87x2g;..\..\..\..\..\..\..\include\rtl87x2g\secure;..\..\..\..\..\..\..\include\rtl87x2g\secure;..\..\..\..\..\..\..\bsp\boot\rtl87x2g;..\..\..\..\..\..\..\bsp\driver;..\..\..\..\..\..\..\bsp\driver\adc\inc;..\..\..\..\..\..\..\bsp\driver\can\inc;..\..\..\..\..\..\..\bsp\driver\codec\src\rtl87x2g;..\..\..\..\..\..\..\bsp\driver\dma\inc;..\..\..\..\..\..\..\bsp\driver\ethernet\inc;..\..\..\..\..\..\..\bsp\driver\gpio\inc;..\..\..\..\..\..\..\bsp\driver\i2c\inc;..\..\..\..\..\..\..\bsp\driver\i2s\inc;..\..\..\..\..\..\..\bsp\driver\ir\inc;..\..\..\..\..\..\..\bsp\driver\iso8716\inc;..\..\..\..\..\..\..\bsp\driver\keyscan\inc;..\..\..\..\..\..\..\bsp\driver\lpc\inc;..\..\..\..\..\..\..\bsp\driver\nvic\inc;..\..\..\..\..\..\..\bsp\driver\pinmux\inc;..\..\..\..\..\..\..\bsp\driver\pinmux\src\rtl87x2g;..\..\..\..\..\..\..\bsp\driver\qdec\inc;..\..\..\..\..\..\..\bsp\driver\rcc\inc;..\..\..\..\..\..\..\bsp\driver\rtc\inc;..\..\..\..\..\..\..\bsp\driver\spi\inc;..\..\..\..\..\..\..\bsp\driver\spi3w\inc;..\..\..\..\..\..\..\bsp\driver\tim\inc;..\..\..\..\..\..\..\bsp\driver\uart\inc;..\..\..\..\..\..\..\bsp\driver\wdt\inc;..\..\..\..\..\..\..\bsp\driver\driver_lib\lib\rtl87x2g\inc;..\..\..\..\..\..\..\bsp\power;..\..\..\..\..\..\..\subsys\display;..\..\..\..\..\..\..\subsys\display\hardware\lcdc\inc;..\..\..\..\..\..\..\subsys\display\hardware\lcdc\src\device\rtl87x2g;..\..\..\..\..\..\..\subsys\display\hardware\idu\inc;..\..\..\..\..\..\..\subsys\display\hardware\idu\src\device\rtl87x2g;..\..\..\..\..\..\..\subsys\display\hardware\idu\inc;..\..\..\..\..\..\..\subsys\display\hardware\idu\src\hal\rtl87x2g;..\..\..\..\..\..\..\subsys\display\hardware\mipi\inc;..\..\..\..\..\..\..\subsys\display\hardware\ppe\inc\rtl87x2g;..\..\..\..\..\..\..\subsys\display\hardware\ppe\src\device\rtl87x2g;..\..\..\..\..\..\..\subsys\display\hardware\segcom\inc;..\..\..\..\..\..\..\include\rtl87x2g\cmsis\Core\Include;..\..\..\..\..\..\..\subsys\bluetooth\bt_host\inc;..\..\..\..\..\..\..\subsys\osif\freertos;..\..\..\..\..\..\..\subsys\osif\rtt;..\..\..\..\..\..\..\subsys\osif;..\..\..\..\..\..\..\subsys\osif\inc;..\..\..\..\..\..\..\subsys\osif\zephyr;..\..\..\src
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  group config
    ../: menu_config.h
  group lib
    ../../../../../../../bin/rtl87x2g/rom_lib/: lowerstack.lib ROM_CMSE_Lib.o ROM_NS.lib
    ../../../../../../../bsp/sdk_lib/lib/rtl87x2g/mdk/: rtl87x2g_sdk.lib
  group device
    ../../../../../../../bsp/boot/rtl87x2g/: startup_rtl.c system_rtl.c
  group peripheral
    ../../../../../../../bsp/driver/rcc/src/rtl87x2g/: rtl_rcc.c
    ../../../../../../../bsp/driver/nvic/src/rtl87x2g/: rtl_nvic.c
    ../../../../../../../bsp/driver/dma/src/rtl_common/: rtl_gdma.c
    ../../../../../../../bsp/driver/driver_lib/lib/rtl87x2g/mdk/: rtl87x2g_io.lib
    ../../../../../../../subsys/display/hardware/idu/src/device/rtl87x2g/: rtl_idu_int.c
    ../../../../../../../subsys/display/hardware/idu/src/device/rtl_common/: rtl_idu.c
  group app
    ../../../src/: app_task.c idu_test.c main_ns.c
