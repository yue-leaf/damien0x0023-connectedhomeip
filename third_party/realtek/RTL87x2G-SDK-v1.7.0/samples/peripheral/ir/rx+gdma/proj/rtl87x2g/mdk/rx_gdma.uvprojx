# Keil uVision project rx_gdma.uvprojx, settings and files
target secure_only_app (6170000::V6.17::.\ARMCompiler6.17)
  device: ARMv81MML_DSP_DP_MVE_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("ARMV81MML") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  AfterMake: after_build_script.bat $J #L @L $P $L
  c flags: Optim=7 v6Lang=3 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X2G
  c misc: -gdwarf-3
  c include: ..\..\..\..\..\..\..\subsys\osif\freertos;..\..\..\..\..\..\..\subsys\osif\inc;..\..\..\..\..\..\..\include\rtl87x2g;..\..\..\..\..\..\..\include\rtl87x2g\config;..\..\..\..\..\..\..\include\rtl87x2g\nsc;..\..\..\..\..\..\..\include\rtl87x2g\cmsis\Core\Include;..\..\..\..\..\..\..\bsp\driver\;..\..\..\..\..\..\..\bsp\driver\nvic\inc;..\..\..\..\..\..\..\bsp\driver\pinmux\inc;..\..\..\..\..\..\..\bsp\driver\rcc\inc;..\..\..\..\..\..\..\bsp\driver\gpio\inc;..\..\..\..\..\..\..\bsp\driver\wdt\inc;..\..\..\..\..\..\..\bsp\driver\spi\inc;..\..\..\..\..\..\..\bsp\driver\tim\inc;..\..\..\..\..\..\..\bsp\driver\uart\inc;..\..\..\..\..\..\..\bsp\driver\i2c\inc;..\..\..\..\..\..\..\bsp\driver\adc\inc;..\..\..\..\..\..\..\bsp\driver\can\inc;..\..\..\..\..\..\..\bsp\driver\dma\inc;..\..\..\..\..\..\..\bsp\driver\ethernet\inc;..\..\..\..\..\..\..\bsp\driver\imdc\inc;..\..\..\..\..\..\..\bsp\driver\ir\inc;..\..\..\..\..\..\..\bsp\driver\iso7816\inc;..\..\..\..\..\..\..\bsp\driver\keyscan\inc;..\..\..\..\..\..\..\bsp\driver\lcdc\inc;..\..\..\..\..\..\..\bsp\driver\lpc\inc;..\..\..\..\..\..\..\bsp\driver\mipi\inc;..\..\..\..\..\..\..\bsp\driver\ppe\inc;..\..\..\..\..\..\..\bsp\driver\qdec\inc;..\..\..\..\..\..\..\bsp\driver\rtc\inc;..\..\..\..\..\..\..\bsp\driver\spi3w\inc;..\..\rtl87x2g;..\..\..\..\..\..\..\bsp\sdk_lib\inc
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  group Device
    ../../../../../../../bsp/boot/rtl87x2g/: startup_rtl.c system_rtl.c
  group CMSIS
    ../../../../../../../include/rtl87x2g/cmsis/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_armv81mml.h core_cm33.h mpu_armv8.h pmu_armv8.h tz_context.h
  group CMSE Library
    ../../../../../../../bin/rtl87x2g/rom_lib/: ROM_CMSE_Lib.o
  group lib
    ../../../../../../../bin/rtl87x2g/rom_lib/: ROM_NS.lib lowerstack.lib
    ../../../../../../../bsp/sdk_lib/lib/rtl87x2g/mdk/: rtl87x2g_sdk.lib
    ../../../../../../../bsp/driver/driver_lib/lib/rtl87x2g/mdk/: rtl87x2g_io.lib
  group peripheral
    ../../../../../../../bsp/driver/rcc/src/rtl87x2g/: rtl_rcc.c
    ../../../../../../../bsp/driver/pinmux/src/rtl87x2g/: rtl_pinmux.c
    ../../../../../../../bsp/driver/gpio/src/rtl_common/: rtl_gpio.c
    ../../../../../../../bsp/driver/ir/src/rtl_common/: rtl_ir.c
    ../../../../../../../bsp/driver/nvic/src/rtl87x2g/: rtl_nvic.c
    ../../../../../../../bsp/driver/dma/src/rtl_common/: rtl_gdma.c
    ../../../../../../../bsp/driver/tim/src/rtl_common/: rtl_tim.c
  group app
    ../../../src/: io_ir.c main_ns.c
