# Keil uVision project tinyml_edge.uvprojx, settings and files
target secure_only_app (6220000::V6.22::.\ArmCompilerforEmbedded6.22)
  device: ARMv81MML_DSP_DP_MVE_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("ARMV81MML") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  AfterMake: after_build_script.bat $J #L @L $P $L
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X2G, DLPS_EN=1, TEMP_BUILD_OS_IN_NS_ROM, TF_LITE_STATIC_MEMORY
  c misc: -Wno-implicit-function-declaration -Wno-reserved-user-defined-literal -gdwarf-3 --include app_flags.h
  c include: ..\..\..\..\..\..\include\rtl87x2g;..\;..\..\..\..\..\..\include\rtl87x2g\config;..\..\..\..\..\..\include\rtl87x2g\nsc;..\..\..\..\..\..\include\rtl87x2g\cmsis\Core\Include;..\..\..\..\..\..\subsys\osif\inc;..\..\..\src;..\..\..\..\..\..\bsp\driver\inc;..\..\..\..\..\..\subsys\bluetooth\gatt_profile\inc\server;..\..\..\..\..\..\subsys\bluetooth\gatt_profile\inc\client;..\..\..\..\..\..\subsys\bluetooth\bt_host\inc;..\..\..\..\..\..\subsys\bluetooth\bt_host\inc;..\..\..\..\..\..\bsp\driver\nvic\inc;..\..\..\..\..\..\bsp\driver\pinmux\inc;..\..\..\..\..\..\bsp\driver\pinmux\src\rtl87x2g;..\..\..\..\..\..\bsp\driver\rcc\inc;..\..\..\..\..\..\bsp\driver;..\..\..\..\..\..\bsp\driver\project\rtl87x2g\inc;..\..\..\..\..\..\bsp\driver\gpio\inc;..\..\..\..\..\..\bsp\driver\wdt\inc;..\..\..\..\..\..\bsp\driver\spi\inc;..\..\..\..\..\..\bsp\driver\tim\inc;..\..\..\..\..\..\bsp\driver\uart\inc;..\..\..\..\..\..\bsp\driver\i2c\inc;..\..\..\..\..\..\bsp\driver\adc\inc;..\..\..\..\..\..\bsp\driver\can\inc;..\..\..\..\..\..\bsp\driver\dma\inc;..\..\..\..\..\..\bsp\driver\ethernet\inc;..\..\..\..\..\..\bsp\driver\imdc\inc;..\..\..\..\..\..\bsp\driver\ir\inc;..\..\..\..\..\..\bsp\driver\iso7816\inc;..\..\..\..\..\..\bsp\driver\keyscan\inc;..\..\..\..\..\..\bsp\driver\lcdc\inc;..\..\..\..\..\..\bsp\driver\lpc\inc;..\..\..\..\..\..\bsp\driver\mipi\inc;..\..\..\..\..\..\bsp\driver\ppe\inc;..\..\..\..\..\..\bsp\driver\qdec\inc;..\..\..\..\..\..\bsp\driver\rtc\inc;..\..\..\..\..\..\bsp\driver\spi3w\inc;..\..\..\..\..\..\bsp\power;..\..\..\..\..\..\bsp\sdk_lib\inc;..\..\..\..\..\..\bin\rtl87x2g\bt_host_image\bt_host_0_0;..\..\..\src\usart_module;..\..\..\src\mem_module;..\..\..\src\tinyml_main
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  group Device
    ../../../../../../bsp/boot/rtl87x2g/: startup_rtl.c system_rtl.c stdlib_wrapper.c
  group CMSE Library
    ../../../../../../bin/rtl87x2g/rom_lib/: ROM_CMSE_Lib.o
  group lib
    ../../../../../../bin/rtl87x2g/rom_lib/: ROM_NS.lib lowerstack.lib
    ../../../../../../bsp/sdk_lib/lib/rtl87x2g/mdk/: rtl87x2g_sdk.lib
    ../../../../../../subsys/bluetooth/gap_ext/lib/rtl87x2g/bt_host_0_0/mdk/: gap_utils.lib
  group driver
    ../../../../../../bsp/driver/pinmux/src/rtl87x2g/: rtl_pinmux.c
    ../../../../../../bsp/power/: io_dlps.c
    ../../../../../../bsp/driver/nvic/src/rtl87x2g/: rtl_nvic.c
    ../../../../../../bsp/driver/rcc/src/rtl87x2g/: rtl_rcc.c
    ../../../../../../bsp/driver/uart/src/rtl_common/: rtl_uart.c
  group app
    ../../../src/: main.c
  group usart_module
    ../../../src/usart_module/: io_uart.c uart_packet_parser.c ts_queue.c
  group mem_module
    ../../../src/mem_module/: psRam_heap.c ts_mem.c malloc_override.c
  group tinyml_main
    ../../../src/tinyml_main/: tinyml_main.c model_process.cpp libts_realtek_cm55.lib
