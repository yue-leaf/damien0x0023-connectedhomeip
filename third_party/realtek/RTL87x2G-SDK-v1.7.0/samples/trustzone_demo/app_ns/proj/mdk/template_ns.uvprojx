# Keil uVision project template_ns.uvprojx, settings and files
target non_secure_app (6170000::V6.17::.\ArmCompilerforEmbedded6.17)
  device: ARMv81MML_DSP_DP_MVE_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("ARMV81MML") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: app_ns +hex
  AfterMake: after_build_script.bat $J #L @L $P $L
  c flags: Optim=7 v6Lang=3 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X2G
  c misc: -gdwarf-3
  c include: ..\..\..\..\..\subsys\osif\inc;..\..\..\..\..\include\rtl87x2g;..\..\..\..\..\include\rtl87x2g\nsc;..\..\..\..\..\include\rtl87x2g\cmsis\Core\Include;..\..\..\..\..\bsp\driver\inc;..\..\..\..\..\bsp\driver\nvic\inc;..\..\..\..\..\bsp\driver\pinmux\inc;..\..\..\..\..\bsp\driver\pinmux\src\rtl87x2g;..\..\..\..\..\bsp\driver\rcc\inc;..\..\..\..\..\bsp\driver;..\..\..\..\..\bsp\driver\project\rtl87x2g\inc;..\..\..\..\..\bsp\driver\gpio\inc;..\..\..\..\..\bsp\driver\wdt\inc;..\..\..\..\..\bsp\driver\spi\inc;..\..\..\..\..\bsp\driver\tim\inc;..\..\..\..\..\bsp\driver\uart\inc;..\..\..\..\..\bsp\driver\i2c\inc;..\..\..\..\..\bsp\driver\adc\inc;..\..\..\..\..\bsp\driver\can\inc;..\..\..\..\..\bsp\driver\dma\inc;..\..\..\..\..\bsp\driver\ethernet\inc;..\..\..\..\..\bsp\driver\imdc\inc;..\..\..\..\..\bsp\driver\ir\inc;..\..\..\..\..\bsp\driver\iso7816\inc;..\..\..\..\..\bsp\driver\keyscan\inc;..\..\..\..\..\bsp\driver\lcdc\inc;..\..\..\..\..\bsp\driver\lpc\inc;..\..\..\..\..\bsp\driver\mipi\inc;..\..\..\..\..\bsp\driver\ppe\inc;..\..\..\..\..\bsp\driver\qdec\inc;..\..\..\..\..\bsp\driver\rtc\inc;..\..\..\..\..\bsp\driver\spi3w\inc;..\..\proj;..\..\src;..\..\..\..\..\bsp\power;..\..\..\..\..\bsp\sdk_lib\inc;..\..\..\..\..\include\rtl87x2g\config\secure;..\..\..\nsc\inc
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  group Device
    ../../../../../bsp/boot/rtl87x2g/: startup_rtl.c system_rtl.c
  group CMSE Library
    ../../../../../bin/rtl87x2g/rom_lib/: ROM_CMSE_Lib.o
    ../../../nsc/lib/: app_s_CMSE_Lib.o
  group lib
    ../../../../../bin/rtl87x2g/rom_lib/: ROM_NS.lib lowerstack.lib
    ../../../../../bsp/sdk_lib/lib/rtl87x2g/mdk/: rtl87x2g_sdk.lib
    ../../../../../bsp/driver/driver_lib/lib/rtl87x2g/mdk/: rtl87x2g_io.lib
  group peripheral
    ../../../../../bsp/driver/pinmux/src/rtl87x2g/: rtl_pinmux.c
    ../../../../../bsp/driver/rcc/src/rtl87x2g/: rtl_rcc.c
    ../../../../../bsp/driver/nvic/src/rtl87x2g/: rtl_nvic.c
    ../../../../../bsp/driver/uart/src/rtl_common/: rtl_uart.c
    ../../../../../bsp/driver/tim/src/rtl_common/: rtl_tim.c
    ../../../../../bsp/power/: io_dlps.c
    ../../../../../bsp/driver/lpc/src/rtl_common/: rtl_lpc.c
    ../../../../../bsp/driver/gpio/src/rtl_common/: rtl_gpio.c
  group app
    ../../src/: main_ns.c app_task.c
