# Keil uVision project secure_app.uvprojx, settings and files
target secure_app (6170000::V6.17::.\ArmCompilerforEmbedded6.17)
  device: ARMv81MML_DSP_DP_MVE_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("ARMV81MML") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: app_s +hex
  BeforeMake: before_build_script.bat
  AfterMake: after_build_script.bat $J #L @L $P $L
  c flags: Optim=7 v6Lang=3 v6LangP=1 wLevel=3
  c define: CONFIG_SOC_SERIES_RTL87X2G
  c misc: -gdwarf-3
  c include: ..\..\..\..\..\include\rtl87x2g\secure;..\..\..\..\..\include\rtl87x2g;..\..\..\..\..\include\rtl87x2g\nsc;..\..\..\..\..\include\rtl87x2g\cmsis\Core\Include;..\..\inc;..\..\proj;..\..\..\..\..\include\rtl87x2g\config\secure;..\..\..\..\..\bsp\sdk_lib\inc;..\..\..\nsc\inc
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\app_s.sct
  group lib
    ../../../../../bin/rtl87x2g/rom_lib/: ROM.lib
  group Device
    ../../../../../bsp/boot/rtl87x2g/: system_rtl_s.c
  group app
    ../../src/: main_s.c
  group nsc
    ../../src/: trustzone_demo_nsc.c
